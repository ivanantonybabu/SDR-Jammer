options:
  parameters:
    author: Ivan Antony Babu
    generate_options: qt_gui
    id: jammer_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '433000000'
  states: {}
- name: cutoff_filter
  id: variable_qtgui_range
  parameters:
    label: cutoff frequency
    start: '5000'
    step: '500'
    stop: '20000'
    value: '8000'
  states: {}
- name: receive_gain
  id: variable_qtgui_range
  parameters:
    label: '"Reciever gain"'
    start: '0'
    step: '1'
    stop: '40'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    label: Transition Width of filter
    start: '1000'
    step: '1000'
    stop: '5000'
    value: '2000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_filter
    gain: '1'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: '[3,0]'
    name: '"de-modulated"'
    type: float
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    dev_addr: '"serial= 313FAF7"'
    gain0: receive_gain
    otw: sc16
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0

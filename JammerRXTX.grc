options:
  parameters:
    author: Ivan Antony Babu
    generate_options: qt_gui
    id: jammer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: cutoff_filter
  id: variable_qtgui_range
  parameters:
    label: cutoff frequency
    start: '2000'
    step: '500'
    stop: '20000'
    value: '8000'
  states: {}
- name: jam_power
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: noise_gain
  id: variable_qtgui_range
  parameters:
    label: '"Noise Gain Usrp"'
    start: '0'
    step: '0.1'
    stop: '1'
    value: '0'
  states: {}
- name: receive_gain
  id: variable_qtgui_range
  parameters:
    label: '"Reciever gain"'
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: signal_gain
  id: variable_qtgui_range
  parameters:
    label: '"Signal Gain"'
    start: '0'
    step: '1'
    stop: '40'
    value: '0'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    label: Transition Width of filter
    start: '1000'
    step: '1000'
    stop: '5000'
    value: '2000'
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: jam_power
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: I:\SKILLS\SDDR RADIO\PROJECT\bassbasic-new-edm-music-beet-mr-sandeep-rock-141616 (1).wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_filter
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: '[0,0]'
    name: '"original"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: '[2,0]'
    name: '"added noise"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: '[3,0]'
    name: '"de-modulated"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: '[1,0]'
    name: '"noise freq"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: '"serial=3136D56"'
    gain0: signal_gain
    otw: sc16
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_sink_1
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: '"serial=3136D56"'
    gain0: 'noise_gain '
    otw: sc16
    samp_rate: samp_rate
    stream_chans: '[0]'
    sync: pc_clock_next_pps
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_freq
    dev_addr: '"serial= 313FA8E"'
    gain0: receive_gain
    otw: sc16
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_nbfm_rx_0, '0', audio_sink_0, '0']
- [analog_nbfm_rx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [analog_nbfm_tx_0, '0', blocks_add_xx_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', qtgui_freq_sink_x_1, '0']
- [analog_noise_source_x_0, '0', uhd_usrp_sink_1, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
